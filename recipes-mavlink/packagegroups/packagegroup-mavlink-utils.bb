# Copyright (C) 2022 esharet <esharet@gmail.com>
# Released under the MIT license (see COPYING.MIT for the terms)

SUMMARY = ""

inherit packagegroup

RDEPENDS_${PN} = " \ 
python-pymavlink \ 
mavlink-router \ 
"

